# IAR project Lib_FatFs_SD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: E:\Documents\Uni\8 periodo\Embarcados\Lab3\cmsis_rtos_examples_cyo_v2\Lib_FatFs_SD; E:\Documents\Uni\8 periodo\Embarcados\Lab3\cmsis_rtos_examples_cyo_v2\Lib_EaBaseBoard; E:\Documents\Uni\8 periodo\Embarcados\Lab3\cmsis_rtos_examples_cyo_v2\Lib_MCU; E:\Documents\Uni\8 periodo\Embarcados\Lab3\cmsis_rtos_examples_cyo_v2\Device\NXP\LPC13xx; E:\Documents\Uni\8 periodo\Embarcados\Lab3\cmsis_rtos_examples_cyo_v2\Drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Lib_FatFs_SD.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Lib_FatFs_SD/src/: ff.c mmc.c
