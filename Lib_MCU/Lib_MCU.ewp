# IAR project Lib_MCU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: inc; ..\Lib_EaBaseBoard\inc; ..\Lib_MCU\inc; ..\Device\NXP\LPC13xx\Include\; ..\Drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Lib_MCU.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: adc.c clkconfig.c gpio.c i2c.c nossoSSP.c nossoTimer.c spi.c ssp.c timer.c timer16.c timer32.c uart.c
